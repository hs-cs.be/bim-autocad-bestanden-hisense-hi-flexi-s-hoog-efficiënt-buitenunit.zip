Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2019-09-02T14:21:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 02 14:21:18 2019 * Host: rvidrea-ro-de * Database: C:\Users\RVI\AppData\Local\Temp\{09624B80-5402-4601-BCCA-C5FA3FF385B8}\ifc * Database version: 5507 * Database creation date: Mon Sep 02 14:21:15 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Sep 02 14:21:15 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 02 14:21:15 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVWT-114FKFSHA, HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN:AVWT-114FKFSHA:1300449
In: V00
Type - Material: Color RGB 000-204-204, Color RGB 216-216-216, Color RGB 080-080-080, Color RGB 024-077-198
Type - Dimensions - Depth: 750 mm; Drain Diameter: 32 mm; Height: 1730 mm; Refrigerant Gas High Diameter: 22.3 mm; Refrigerant Gas Low Diameter: 25.4 mm; Refrigerant Liquid Diameter: 12.7 mm; Width: 1210 mm
Type - Electrical - ELB Nominal Current: 40 A; Hertz: 50 Hz; Phase: 3; Voltage: 415 V
Type - Identity Data - Article Type: AVWT-114FKFSHA; Base Family Version: 12.01; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 4.0; ETIM Article Class: EC001213; Family Version: 12.01; Manufacturer: Hisense; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVWT-114FKFSHA; OmniClass Number: 23.75.10.17.17; OmniClass Title: Combined Heating/Cooking Units; Revit Version: 2017; Type Name: AVWT-114FKFSHA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Green: Color RGB 000-204-204; Grey: Color RGB 080-080-080; White: Color RGB 216-216-216
Type - Mechanical - Loads - Airflow Rate (m3/min): 200; Cooling Capacity (kW): 33.5; Cooling EER (kW/kW): 4.62; Cooling Power Input (kW): 7.25; DX-Cooling Maximum: 52 DB; DX-Cooling Minimum: -10 DB; Energy Efficiency ESEER: 9.53; Energy Efficiency SCOP: 4.25; Energy Efficiency SEER: 8.56; Maximum Heating Capacity (kW): 37.5; Maximum Heating COP (kW/kW): 5; Maximum Heating Power Input (kW): 7.5; Nominal Heating Capacity (kW): 33.5; Nominal Heating COP (kW/kW): 5.4; Nominal Heating Power Input (kW): 6.2; Sound Pressure Level (dB(A)): 62; Unit Weight (kg): 290
Type - Other - Category: Mechanical Equipment; Compressor Quantity: 1; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN; Fan Quantity: 2; Refrigerant Charge (kg): 8.8; Refrigerant Type: R410A
Type - Text - Article Description: Heat pump outdoor unit; Manufacturer Art. No.: AVWT-114FKFSHA; Product Line: S Series Hi-COP 3 Pipe
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 19.6041 m2; Volume: 9.60461 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Flow Refrigerant Gas High: 0 m3/s; Flow Refrigerant Gas Low: 0 m3/s; Flow Refrigerant Liquid: 0 m3/s; System Classification: Sanitary,Power,Undefined
Other - Angle: 0 deg; Back Clearance Safe: 300 mm; Bottom Side Connectors: no; Family: HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN: AVWT-114FKFSHA; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN: AVWT-114FKFSHA; Fron Clearance Safe: 500 mm; L1: 144 mm; L2: 135 mm; Left Clearance Safe: 200 mm; Right Clearance Safe: 200 mm; Top Clearance Safe: 1500 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN: AVWT-114FKFSHA; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVWT114FKFSHA-136FKFSHA_INT-EN: AVWT-114FKFSHA
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Back Clearance: 300 mm; Front Clearance: 500 mm; Front Side Connectors: yes; Left Clearance: 200 mm; Right Clearance: 200 mm; Service Space: no; Top Clearance: 1500 mm
