Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2019-09-02T14:21:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 02 14:21:56 2019 * Host: rvidrea-ro-de * Database: C:\Users\RVI\AppData\Local\Temp\{1F1D8DBC-0320-4CBA-B8F0-5CA2E8DF32C6}\ifc * Database version: 5507 * Database creation date: Mon Sep 02 14:21:54 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Sep 02 14:21:55 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 02 14:21:55 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVWT-154FKFSHA, HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN:AVWT-154FKFSHA:1314475
In: V00
Type - Material: Color RGB 216-216-216, Color RGB 080-080-080, Color RGB 024-077-198, Color RGB 000-204-204
Type - Dimensions - Depth: 750 mm; Drain Diameter: 32 mm; Height: 1730 mm; Refrigerant Gas High Diameter: 22.3 mm; Refrigerant Gas Low Diameter: 28.6 mm; Refrigerant Liquid Diameter: 12.7 mm; Width: 1350 mm
Type - Electrical - ELB Nominal Current: 50 A; Hertz: 50 Hz; Phase: 3; Voltage: 415 V
Type - Identity Data - Article Type: AVWT-154FKFSHA; Base Family Version: 12.01; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 4.0; ETIM Article Class: EC001213; Family Version: 12.01; Manufacturer: Hisense; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVWT-154FKFSHA; OmniClass Number: 23.75.10.17.17; OmniClass Title: Combined Heating/Cooking Units; Revit Version: 2017; Type Name: AVWT-154FKFSHA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Green: Color RGB 000-204-204; Grey: Color RGB 080-080-080; White: Color RGB 216-216-216
Type - Mechanical - Loads - Airflow Rate (m3/min): 267; Cooling Capacity (kW): 45; Cooling EER (kW/kW): 4.01; Cooling Power Input (kW): 11.22; DX-Cooling Maximum: 52 DB; DX-Cooling Minimum: -10 DB; Energy Efficiency ESEER: 9.36; Energy Efficiency SCOP: 3.83; Energy Efficiency SEER: 7.98; Maximum Heating Capacity (kW): 50; Maximum Heating COP (kW/kW): 4.21; Maximum Heating Power Input (kW): 11.88; Nominal Heating Capacity (kW): 45; Nominal Heating COP (kW/kW): 4.4; Nominal Heating Power Input (kW): 10.23; Sound Pressure Level (dB(A)): 62; Unit Weight (kg): 369
Type - Other - Category: Mechanical Equipment; Compressor Quantity: 2; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN; Fan Quantity: 2; Refrigerant Charge (kg): 9.8; Refrigerant Type: R410A
Type - Text - Article Description: Heat pump outdoor unit; Manufacturer Art. No.: AVWT-154FKFSHA; Product Line: S Series Hi-COP 3 Pipe
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 21.0621 m2; Volume: 10.4866 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Flow Refrigerant Gas High: 0 m3/s; Flow Refrigerant Gas Low: 0 m3/s; Flow Refrigerant Liquid: 0 m3/s; System Classification: Sanitary,Power,Undefined
Other - Angle: 0 deg; Back Clearance Safe: 300 mm; Bottom Side Connections: no; Family: HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN: AVWT-154FKFSHA; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN: AVWT-154FKFSHA; Front Clearance Safe: 500 mm; L1: 157 mm; L2: 152 mm; Left Clearance Safe: 200 mm; Right Clearance Safe: 200 mm; Top Clearance Safe: 1500 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN: AVWT-154FKFSHA; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVWT154FKFSHA-170FKFSHA_INT-EN: AVWT-154FKFSHA
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Back Clearance: 300 mm; Front Clearance: 500 mm; Front Side Connectors: yes; Left Clearance: 200 mm; Right Clearance: 200 mm; Service Space: no; Top Clearance: 1500 mm
